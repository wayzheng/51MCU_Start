# Keil uVision project music_demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: music_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h key.c key.h Timer0.c Timer0.h Nixie.c Nixie.h Buzzer.c Buzzer.h
