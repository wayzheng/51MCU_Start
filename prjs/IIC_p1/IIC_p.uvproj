# Keil uVision project IIC_p.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IIC_p +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h key.c key.h Nixie.c Nixie.h Timer0.c Timer0.h AT24C02.c AT24C02.h I2C.c I2C.h
