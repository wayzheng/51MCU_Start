# Keil uVision project Ds1302_clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Ds1302_clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h DS1302.c DS1302.h Delay.c Delay.h key.c key.h Timer0.c Timer0.h IsLeapYear.c IsLeapYear.h
