# Keil uVision project temp.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temp +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: AT24C02.c AT24C02.h Delay.c Delay.h DS18B20.c DS18B20.h I2C.c I2C.h LCD1602.c LCD1602.h main.c OneWire.c OneWire.h key.c key.h Timer0.c Timer0.h
